# Keil uVision project FreeRTOS_demo.uvprojx, settings and files
target FreeRTOS_demo (5060960::V5.06 update 7 (build 960)::.\ARMCOMPILER506)
  device: STM32H750VBTx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.4.0.0
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x24000000-0x2407FFFF) IROM(0x8000000-0x801FFFF) CLOCK(12000000) FPU3(DFPU) CPUTYPE("Cortex-M7") ELITTLE TZ
  output: FreeRTOS_demo +hex
  c flags: Optim=4 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_PWR_LDO_SUPPLY,USE_HAL_DRIVER,STM32H750xx,STM32_THREAD_SAFE_STRATEGY=4,EXT_FLASH_SPI
  c include: ../Core/Inc;../FATFS/Target;../FATFS/App;../Drivers/STM32H7xx_HAL_Driver/Inc;../Drivers/STM32H7xx_HAL_Driver/Inc/Legacy;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;../Middlewares/Third_Party/FatFs/src;../Drivers/CMSIS/Device/ST/STM32H7xx/Include;../Drivers/CMSIS/Include;../Drivers/User/key;..\Middlewares\Third_Party\lvgl;..\Middlewares\Third_Party
  asm include: ../Core/Inc;../FATFS/Target;../FATFS/App;../Drivers/STM32H7xx_HAL_Driver/Inc;../Drivers/STM32H7xx_HAL_Driver/Inc/Legacy;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;../Middlewares/Third_Party/FatFs/src;../Drivers/CMSIS/Device/ST/STM32H7xx/Include;../Drivers/CMSIS/Include
  library: MicroLIB
  memory RVCT1: ROM 0x90000000 size 0x800000
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x80000
  group Application/MDK-ARM
    ./: startup_stm32h750xx.s armlib_lock_glue.c
  group Application/User/Core
    ../Core/Src/: main.c gpio.c freertos.c dcmi.c dma.c memorymap.c quadspi.c sdmmc.c spi.c tim.c usart.c usb_otg.c stm32h7xx_it.c stm32h7xx_hal_msp.c lvgl.c
  group Application/User/FATFS/Target
    ../FATFS/Target/: bsp_driver_sd.c sd_diskio.c
  group Application/User/FATFS/App
    ../FATFS/App/: fatfs.c
  group Drivers/STM32H7xx_HAL_Driver
    ../Drivers/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal_cortex.c stm32h7xx_hal_dcmi.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_flash.c stm32h7xx_hal_flash_ex.c stm32h7xx_hal_gpio.c stm32h7xx_hal_hsem.c stm32h7xx_hal_dma.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_mdma.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal.c stm32h7xx_hal_i2c.c stm32h7xx_hal_i2c_ex.c stm32h7xx_hal_exti.c stm32h7xx_hal_qspi.c stm32h7xx_ll_delayblock.c stm32h7xx_ll_sdmmc.c stm32h7xx_hal_sd.c stm32h7xx_hal_sd_ex.c stm32h7xx_hal_mmc.c stm32h7xx_hal_mmc_ex.c stm32h7xx_hal_spi.c stm32h7xx_hal_spi_ex.c stm32h7xx_hal_tim.c stm32h7xx_hal_tim_ex.c stm32h7xx_hal_uart.c stm32h7xx_hal_uart_ex.c stm32h7xx_hal_pcd.c stm32h7xx_hal_pcd_ex.c stm32h7xx_ll_usb.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32h7xx.c
  group Middlewares/FatFs
    ../Middlewares/Third_Party/FatFs/src/: diskio.c ff.c ff_gen_drv.c
    ../Middlewares/Third_Party/FatFs/src/option/: syscall.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
  group Drivers/User/key
    ../Drivers/User/key/: key.c
  group Middlewares/lvgl
    ../Middlewares/Third_Party/lvgl/src/core/: lv_group.c lv_obj.c lv_obj_class.c lv_obj_draw.c lv_obj_event.c lv_obj_id_builtin.c lv_obj_pos.c lv_obj_property.c lv_obj_scroll.c lv_obj_style.c lv_obj_style_gen.c lv_obj_tree.c lv_refr.c
    ../Middlewares/Third_Party/lvgl/src/: lv_init.c
    ../Middlewares/Third_Party/lvgl/src/display/: lv_display.c
    ../Middlewares/Third_Party/lvgl/src/draw/: lv_draw.c lv_draw_3d.c lv_draw_arc.c lv_draw_buf.c lv_draw_image.c lv_draw_label.c lv_draw_line.c lv_draw_mask.c lv_draw_rect.c lv_draw_triangle.c lv_draw_vector.c lv_image_decoder.c
    ../Middlewares/Third_Party/lvgl/src/drivers/display/st7789/: lv_st7789.c
    ../Middlewares/Third_Party/lvgl/src/font/: lv_binfont_loader.c lv_font.c lv_font_dejavu_16_persian_hebrew.c lv_font_fmt_txt.c lv_font_montserrat_8.c lv_font_montserrat_10.c lv_font_montserrat_12.c lv_font_montserrat_14.c lv_font_montserrat_14_aligned.c lv_font_montserrat_16.c lv_font_montserrat_18.c lv_font_montserrat_20.c lv_font_montserrat_22.c lv_font_montserrat_24.c lv_font_montserrat_26.c lv_font_montserrat_28.c lv_font_montserrat_28_compressed.c lv_font_montserrat_30.c lv_font_montserrat_32.c lv_font_montserrat_34.c lv_font_montserrat_36.c lv_font_montserrat_38.c lv_font_montserrat_40.c lv_font_montserrat_42.c lv_font_montserrat_44.c lv_font_montserrat_46.c lv_font_montserrat_48.c lv_font_simsun_14_cjk.c lv_font_simsun_16_cjk.c lv_font_source_han_sans_sc_14_cjk.c lv_font_source_han_sans_sc_16_cjk.c lv_font_unscii_8.c lv_font_unscii_16.c
    ../Middlewares/Third_Party/lvgl/src/indev/: lv_indev.c lv_indev_gesture.c lv_indev_scroll.c
    ../Middlewares/Third_Party/lvgl/src/layouts/: lv_layout.c
    ../Middlewares/Third_Party/lvgl/src/layouts/grid/: lv_grid.c
    ../Middlewares/Third_Party/lvgl/src/layouts/flex/: lv_flex.c
    ../Middlewares/Third_Party/lvgl/src/misc/: lv_anim.c lv_anim_timeline.c lv_area.c lv_array.c lv_async.c lv_bidi.c lv_circle_buf.c lv_color.c lv_color_op.c lv_event.c lv_fs.c lv_grad.c lv_iter.c lv_ll.c lv_log.c lv_lru.c lv_math.c lv_matrix.c lv_palette.c lv_profiler_builtin.c lv_rb.c lv_style.c lv_style_gen.c lv_templ.c lv_text.c lv_text_ap.c lv_timer.c lv_tree.c lv_utils.c
    ../Middlewares/Third_Party/lvgl/src/misc/cache/: lv_cache.c lv_cache_entry.c
    ../Middlewares/Third_Party/lvgl/src/osal/: lv_cmsis_rtos2.c lv_freertos.c lv_linux.c lv_mqx.c lv_os.c lv_os_none.c lv_pthread.c lv_rtthread.c lv_sdl2.c lv_windows.c
    ../Middlewares/Third_Party/lvgl/src/widgets/bar/: lv_bar.c
    ../Middlewares/Third_Party/lvgl/src/widgets/3dtexture/: lv_3dtexture.c
    ../Middlewares/Third_Party/lvgl/src/widgets/animimage/: lv_animimage.c
    ../Middlewares/Third_Party/lvgl/src/widgets/arc/: lv_arc.c
    ../Middlewares/Third_Party/lvgl/src/widgets/button/: lv_button.c
    ../Middlewares/Third_Party/lvgl/src/widgets/buttonmatrix/: lv_buttonmatrix.c
    ../Middlewares/Third_Party/lvgl/src/widgets/calendar/: lv_calendar.c lv_calendar_chinese.c lv_calendar_header_arrow.c lv_calendar_header_dropdown.c
    ../Middlewares/Third_Party/lvgl/src/widgets/canvas/: lv_canvas.c
    ../Middlewares/Third_Party/lvgl/src/widgets/chart/: lv_chart.c
    ../Middlewares/Third_Party/lvgl/src/widgets/checkbox/: lv_checkbox.c
    ../Middlewares/Third_Party/lvgl/src/widgets/dropdown/: lv_dropdown.c
    ../Middlewares/Third_Party/lvgl/src/widgets/image/: lv_image.c
    ../Middlewares/Third_Party/lvgl/src/widgets/imagebutton/: lv_imagebutton.c
    ../Middlewares/Third_Party/lvgl/src/widgets/keyboard/: lv_keyboard.c
    ../Middlewares/Third_Party/lvgl/src/widgets/label/: lv_label.c
    ../Middlewares/Third_Party/lvgl/src/widgets/led/: lv_led.c
    ../Middlewares/Third_Party/lvgl/src/widgets/line/: lv_line.c
    ../Middlewares/Third_Party/lvgl/src/widgets/list/: lv_list.c
    ../Middlewares/Third_Party/lvgl/src/widgets/lottie/: lv_lottie.c
    ../Middlewares/Third_Party/lvgl/src/widgets/menu/: lv_menu.c
    ../Middlewares/Third_Party/lvgl/src/widgets/msgbox/: lv_msgbox.c
    ../Middlewares/Third_Party/lvgl/src/widgets/objx_templ/: lv_objx_templ.c
    ../Middlewares/Third_Party/lvgl/src/widgets/property/: lv_animimage_properties.c lv_dropdown_properties.c lv_image_properties.c lv_keyboard_properties.c lv_label_properties.c lv_obj_properties.c lv_roller_properties.c lv_slider_properties.c lv_style_properties.c lv_textarea_properties.c
    ../Middlewares/Third_Party/lvgl/src/widgets/roller/: lv_roller.c
    ../Middlewares/Third_Party/lvgl/src/widgets/scale/: lv_scale.c
    ../Middlewares/Third_Party/lvgl/src/widgets/slider/: lv_slider.c
    ../Middlewares/Third_Party/lvgl/src/widgets/span/: lv_span.c
    ../Middlewares/Third_Party/lvgl/src/widgets/spinbox/: lv_spinbox.c
    ../Middlewares/Third_Party/lvgl/src/widgets/spinner/: lv_spinner.c
    ../Middlewares/Third_Party/lvgl/src/widgets/switch/: lv_switch.c
    ../Middlewares/Third_Party/lvgl/src/widgets/table/: lv_table.c
    ../Middlewares/Third_Party/lvgl/src/widgets/tabview/: lv_tabview.c
    ../Middlewares/Third_Party/lvgl/src/widgets/textarea/: lv_textarea.c
    ../Middlewares/Third_Party/lvgl/src/widgets/tileview/: lv_tileview.c
    ../Middlewares/Third_Party/lvgl/src/widgets/win/: lv_win.c
    ../Middlewares/Third_Party/lvgl/src/tick/: lv_tick.c
    ../Middlewares/Third_Party/lvgl/src/themes/default/: lv_theme_default.c
    ../Middlewares/Third_Party/lvgl/src/themes/: lv_theme.c
    ../Middlewares/Third_Party/lvgl/src/stdlib/: lv_mem.c
    ../Middlewares/Third_Party/lvgl/src/stdlib/clib/: lv_mem_core_clib.c lv_sprintf_clib.c lv_string_clib.c
    ../Middlewares/Third_Party/lvgl/src/others/file_explorer/: lv_file_explorer.c
    ../Middlewares/Third_Party/lvgl/src/others/font_manager/: lv_font_manager.c lv_font_manager_recycle.c
    ../Middlewares/Third_Party/lvgl/src/others/fragment/: lv_fragment.c lv_fragment_manager.c
    ../Middlewares/Third_Party/lvgl/src/others/gridnav/: lv_gridnav.c
    ../Middlewares/Third_Party/lvgl/src/others/ime/: lv_ime_pinyin.c
    ../Middlewares/Third_Party/lvgl/src/others/imgfont/: lv_imgfont.c
    ../Middlewares/Third_Party/lvgl/src/others/monkey/: lv_monkey.c
    ../Middlewares/Third_Party/lvgl/src/others/observer/: lv_observer.c
    ../Middlewares/Third_Party/lvgl/src/others/snapshot/: lv_snapshot.c
    ../Middlewares/Third_Party/lvgl/src/others/sysmon/: lv_sysmon.c
    ../Middlewares/Third_Party/lvgl/src/others/test/: lv_test_display.c lv_test_helpers.c lv_test_indev.c lv_test_indev_gesture.c lv_test_screenshot_compare.c
    ../Middlewares/Third_Party/lvgl/src/others/vg_lite_tvg/: vg_lite_matrix.c
    ../Middlewares/Third_Party/lvgl/src/others/xml/: lv_xml.c lv_xml_base_types.c lv_xml_component.c lv_xml_parser.c lv_xml_style.c lv_xml_update.c lv_xml_utils.c lv_xml_widget.c
    ../Middlewares/Third_Party/lvgl/src/others/xml/parsers/: lv_xml_arc_parser.c lv_xml_bar_parser.c lv_xml_button_parser.c lv_xml_buttonmatrix_parser.c lv_xml_calendar_parser.c lv_xml_canvas_parser.c lv_xml_chart_parser.c lv_xml_checkbox_parser.c lv_xml_dropdown_parser.c lv_xml_event_parser.c lv_xml_image_parser.c lv_xml_keyboard_parser.c lv_xml_label_parser.c lv_xml_obj_parser.c lv_xml_roller_parser.c lv_xml_scale_parser.c lv_xml_slider_parser.c lv_xml_spangroup_parser.c lv_xml_table_parser.c lv_xml_tabview_parser.c lv_xml_textarea_parser.c
    ../Middlewares/Third_Party/lvgl/src/misc/cache/class/: lv_cache_lru_ll.c lv_cache_lru_rb.c
    ../Middlewares/Third_Party/lvgl/src/misc/cache/instance/: lv_image_cache.c lv_image_header_cache.c
    ../Middlewares/Third_Party/lvgl/src/stdlib/builtin/: lv_mem_core_builtin.c lv_sprintf_builtin.c lv_string_builtin.c lv_tlsf.c
    ../Middlewares/Third_Party/lvgl/src/stdlib/micropython/: lv_mem_core_micropython.c
    ../Middlewares/Third_Party/lvgl/src/stdlib/rtthread/: lv_mem_core_rtthread.c lv_sprintf_rtthread.c lv_string_rtthread.c
    ../Middlewares/Third_Party/lvgl/src/stdlib/uefi/: lv_mem_core_uefi.c
    ../Middlewares/Third_Party/lvgl/src/libs/bin_decoder/: lv_bin_decoder.c
    ../Middlewares/Third_Party/lvgl/src/draw/sw/: lv_draw_sw.c lv_draw_sw_arc.c lv_draw_sw_border.c lv_draw_sw_box_shadow.c lv_draw_sw_fill.c lv_draw_sw_grad.c lv_draw_sw_img.c lv_draw_sw_letter.c lv_draw_sw_line.c lv_draw_sw_mask.c lv_draw_sw_mask_rect.c lv_draw_sw_transform.c lv_draw_sw_triangle.c lv_draw_sw_utils.c lv_draw_sw_vector.c
    ../Middlewares/Third_Party/lvgl/src/draw/sw/blend/: lv_draw_sw_blend.c lv_draw_sw_blend_to_al88.c lv_draw_sw_blend_to_argb8888.c lv_draw_sw_blend_to_argb8888_premultiplied.c lv_draw_sw_blend_to_i1.c lv_draw_sw_blend_to_l8.c lv_draw_sw_blend_to_rgb565.c lv_draw_sw_blend_to_rgb565_swapped.c lv_draw_sw_blend_to_rgb888.c
    ../Middlewares/Third_Party/lvgl/src/themes/mono/: lv_theme_mono.c
    ../Middlewares/Third_Party/lvgl/src/drivers/display/lcd/: lv_lcd_generic_mipi.c
    ../Middlewares/Third_Party/lvgl/src/themes/simple/: lv_theme_simple.c
    ../Middlewares/Third_Party/lvgl/: lv_port_disp.c
  group Middlewares/lvgl_demos
    ../Middlewares/Third_Party/lvgl/demos/: lv_demos.c
    ../Middlewares/Third_Party/lvgl/demos/benchmark/: lv_demo_benchmark.c
    ../Middlewares/Third_Party/lvgl/demos/benchmark/assets/: img_benchmark_avatar.c img_benchmark_lvgl_logo_argb.c img_benchmark_lvgl_logo_rgb.c lv_font_benchmark_montserrat_12_aligned.c lv_font_benchmark_montserrat_14_aligned.c lv_font_benchmark_montserrat_16_aligned.c lv_font_benchmark_montserrat_18_aligned.c lv_font_benchmark_montserrat_20_aligned.c lv_font_benchmark_montserrat_24_aligned.c lv_font_benchmark_montserrat_26_aligned.c
    ../Middlewares/Third_Party/lvgl/demos/widgets/: lv_demo_widgets.c
    ../Middlewares/Third_Party/lvgl/demos/widgets/assets/: img_clothes.c img_demo_widgets_avatar.c img_demo_widgets_needle.c img_lvgl_logo.c
    ../Middlewares/Third_Party/lvgl/demos/music/: lv_demo_music.c lv_demo_music_list.c lv_demo_music_main.c
    ../Middlewares/Third_Party/lvgl/demos/music/assets/: img_lv_demo_music_btn_corner_large.c img_lv_demo_music_btn_list_pause.c img_lv_demo_music_btn_list_pause_large.c img_lv_demo_music_btn_list_play.c img_lv_demo_music_btn_list_play_large.c img_lv_demo_music_btn_loop.c img_lv_demo_music_btn_loop_large.c img_lv_demo_music_btn_next.c img_lv_demo_music_btn_next_large.c img_lv_demo_music_btn_pause.c img_lv_demo_music_btn_pause_large.c img_lv_demo_music_btn_play.c img_lv_demo_music_btn_play_large.c img_lv_demo_music_btn_prev.c img_lv_demo_music_btn_prev_large.c img_lv_demo_music_btn_rnd.c img_lv_demo_music_btn_rnd_large.c img_lv_demo_music_corner_left.c img_lv_demo_music_corner_left_large.c img_lv_demo_music_corner_right.c img_lv_demo_music_corner_right_large.c img_lv_demo_music_cover_1.c img_lv_demo_music_cover_1_large.c img_lv_demo_music_cover_2.c img_lv_demo_music_cover_2_large.c img_lv_demo_music_cover_3.c img_lv_demo_music_cover_3_large.c img_lv_demo_music_icon_1.c img_lv_demo_music_icon_1_large.c img_lv_demo_music_icon_2.c img_lv_demo_music_icon_2_large.c img_lv_demo_music_icon_3.c img_lv_demo_music_icon_3_large.c img_lv_demo_music_icon_4.c img_lv_demo_music_icon_4_large.c img_lv_demo_music_list_border.c img_lv_demo_music_list_border_large.c img_lv_demo_music_logo.c img_lv_demo_music_slider_knob.c img_lv_demo_music_slider_knob_large.c img_lv_demo_music_wave_bottom.c img_lv_demo_music_wave_bottom_large.c img_lv_demo_music_wave_top.c img_lv_demo_music_wave_top_large.c
software components: CMSIS:CORE 6.1.0
